Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: ae299eda-f041-4b9b-a29a-1149cb6f6006, NumberOfSaves: 1]
File name: 0001
Time: 2025-05-21T08:48:40+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11228130_OER_KWT7112iG_GRGR:36711202_OER_11228130_KWT7112iG_GRGR, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel, z_Miele_Design_GRGR, z_Miele_Design_Glass, z_Miele_Design_Steel_Chrom, z_Miele_Connection_Electric, Spruce, Polypropylene
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 595 mm; Height: 455 mm; Depth: 559 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 36711202_OER_11228130_KWT7112iG_GRGR; sets with these values: 2
